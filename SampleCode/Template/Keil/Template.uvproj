# Keil uVision project Template.uvproj, settings and files
target MASTER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: MASTER +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ENABLE_MODBUS_MASTER
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc;..\..\Template;..\modbus\include;..\modbus\rtu;..\modbus\ascii;..\port
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c misc_config.c
  group FreeModbus
    ../port/: port.c
    ../modbus/tcp/: mbtcp.c
    ../modbus/rtu/: mbcrc.c
    ../modbus/functions/: mbutils.c mbfuncother.c mbfuncdiag.c
    ../modbus/ascii/: mbascii.c
  group FreeModbusSlave
    ../modbus/: mb.c
    ../modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c
    ../modbus/rtu/: mbrtu.c
    ../port/: portevent.c portserial.c porttimer.c
    ../: mb_slave.c
  group FreeModbuMaster
    ../modbus/: mb_m.c
    ../modbus/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c
    ../modbus/rtu/: mbrtu_m.c
    ../: mb_master.c
    ../port/: portevent_m.c portserial_m.c porttimer_m.c
target SLAVE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032SE3AE Nuvoton
  cpu: as above
  output: SLAVE +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ENABLE_MODBUS_SLAVE
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: as above
